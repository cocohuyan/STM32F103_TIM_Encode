# Keil uVision project STM32_Encoder.uvprojx, settings and files
target STM32_Encoder (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EncodeTIM4 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL
  c include: ..\;..\Libraries\CMSIS\Core;..\Libraries\CMSIS\Core\CM3;..\Libraries\CMSIS\Core\CM3\startup;..\Libraries\CMSIS\Core\CM3\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\APP;..\APP\Sprint;..\APP\Sprint;..\APP\SEGGER_RTT_V788j\Config;..\APP\SEGGER_RTT_V788j\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c
  group RVMDK
    ../Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group App
    ../APP/: main.c stm32f10x_it.c BSP_Config.c
  group Sprint
    ../APP/Sprint/: send_DATA.c
  group CRC
    ../APP/: CRC.c
  group OLED
    ../APP/: oled.c
  group Eeprom
    ../APP/: Eeprom.c
  group Segger
    ../APP/SEGGER_RTT_V788j/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
